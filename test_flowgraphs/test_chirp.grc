options:
  parameters:
    generate_options: qt_gui
    id: test_chirp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: chirp_freq
  id: variable
  parameters:
    value: '30_000'
  states: {}
- name: chirp_speed
  id: variable
  parameters:
    value: '10'
  states: {}
- name: nco
  id: variable
  parameters:
    value: '120_000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200_000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2 * math.pi * chirp_freq) / (samp_rate)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: chirp_speed
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: fau_modem_fau_sink_0
  id: fau_modem_fau_sink
  parameters:
    allow_unreserved: 'True'
    bd_samples: '8192'
    drain_on_stop: 'True'
    nco_freq: nco - (chirp_freq //2)
    num_bds: '16'
    poll_timeout: '20.0'
    prefill_bds: '4'
    samp_rate: samp_rate
    tx_scale: '0.1'
    verbose: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', fau_modem_fau_sink_0, '0']
- [analog_sig_source_x_0, '0', analog_frequency_modulator_fc_0, '0']

metadata:
  file_format: 1
